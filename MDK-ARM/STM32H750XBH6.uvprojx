# Keil uVision project STM32H750XBH6.uvprojx, settings and files
target STM32H750XBH6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H750XBH6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Drivers\User\Inc;..\Drivers\FreeRTOS\include;..\Drivers\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\Drivers\FreeGUI;..\Drivers\FATFS\source;..\Drivers\BLE;..\Drivers\LVGL;..\Drivers\LVGL\src;..\Drivers\LVGL\examples\porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Drivers/User
    ../Drivers/User/Src/: rtos_task.c led.c usart.c sdmmc_sd.c sdram.c lcd_fonts.c lcd_image.c lcd_spi_169.c usart2.c tim5.c
    ../Drivers/User/Inc/: rtos_task.h led.h usart.h sdram.h lcd_fonts.h lcd_image.h lcd_spi_169.h usart2.h tim5.h
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Core/Inc/: stm32h7xx_hal_conf.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_smbus_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_fmc.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usb.c
  group Drivers/FreeRTOS
    ../Drivers/FreeRTOS/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c croutine.c
    ../Drivers/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Drivers/FreeRTOS/portable/MemMang/: heap_4.c
    ../Drivers/FreeRTOS/include/: FreeRTOSConfig.h
  group Drivers/FATFS
    ../Drivers/FATFS/source/: diskio.c diskio.h ff.c ff.h ffconf.h
  group Drivers/LVGL/src
    ../Drivers/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Drivers/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Drivers/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Drivers/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Drivers/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Drivers/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Drivers/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Drivers/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Drivers/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Drivers/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Drivers/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Drivers/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Drivers/LVGL/src/extra/: lv_extra.c
    ../Drivers/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Drivers/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Drivers/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Drivers/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Drivers/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Drivers/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Drivers/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Drivers/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Drivers/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Drivers/LVGL/src/extra/widgets/led/: lv_led.c
    ../Drivers/LVGL/src/extra/widgets/list/: lv_list.c
    ../Drivers/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Drivers/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Drivers/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Drivers/LVGL/src/extra/widgets/span/: lv_span.c
    ../Drivers/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Drivers/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Drivers/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Drivers/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Drivers/LVGL/src/extra/widgets/win/: lv_win.c
    ../Drivers/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Drivers/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Drivers/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Drivers/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c lv_dclock.c lv_textprogress.c lv_analogclock.c
  group Drivers/LVGL/porting
    ../Drivers/LVGL/: lvgl.h lv_conf.h
    ../Drivers/LVGL/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h lv_port_fs.c lv_port_fs.h
  group Drivers/LVGL/ui
    ../Drivers/LVGL/ui/src/custom/: custom.c
    ../Drivers/LVGL/ui/src/generated/guider_fonts/: lv_font_Antonio_Regular_67.c lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_montserratMedium_27.c lv_font_montserratMedium_32.c lv_font_montserratMedium_47.c
    ../Drivers/LVGL/ui/src/generated/images/: _xs_alpha_50x50.c
    ../Drivers/LVGL/ui/src/generated/: events_init.c gui_guider.c setup_scr_control_scr.c setup_scr_led_scr.c setup_scr_timer_scr.c setup_scr_tz_scr.c setup_scr_watch_scr.c widgets_init.c
  group Drivers/letter_shell
    ../Drivers/letter_shell/src/: shell.c shell.h shell_cfg.h shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h shell_port.c shell_port.h user_cmd.c user_cmd.h
    ../Drivers/letter_shell/extensions/log/: log.c log.h
  group Drivers/link_list
    ../Drivers/link_list/: link_list.c link_list.h
  group README
    ../: README.md
target EXT_Flash_SPI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.1
  cpu: as above
  output: STM32H750XBH6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,EXT_Flash_SPI
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Drivers\User\Inc;..\Drivers\FATFS\source;..\Drivers\FreeRTOS\include;..\Drivers\FreeRTOS\portable;..\Drivers\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\Drivers\LVGL;..\Drivers\LVGL\src;..\Drivers\LVGL\examples\porting;..\Drivers\LVGL\ui\src\custom;..\Drivers\LVGL\ui\src\generated\guider_customer_fonts;..\Drivers\LVGL\ui\src\generated\guider_fonts;..\Drivers\LVGL\ui\src\generated\images;..\Drivers\LVGL\ui\src\generated;..\Drivers\LVGL\demos;..\Drivers\link_list;..\Drivers\LVGL\src\misc;..\Drivers\letter_shell\src;..\Drivers\letter_shell\extensions\log
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 6.1.0
